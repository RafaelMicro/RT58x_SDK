# Keil uVision project ToggleSubGBLE_FTD.uvprojx, settings and files
target ToggleSubGBLE_FTD (6160000::V6.16::ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: Toggle_SubG_BLE_FTD +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=Bin\@L.bin !L
  c flags: Optim=6 v6Lang=3 v6LangP=3 wLevel=1
  c define: NDEBUG,OPENTHREAD_FTD, OPENTHREAD_PROJECT_CORE_CONFIG_FILE='\"openthread-core-RT58x-config.h\"' ,OPENTHREAD_CONFIG_FILE='\"openthread-core-RT58x-config.h\"', OPENTHREAD_CORE_CONFIG_PLATFORM_CHECK_FILE='\"openthread-core-RT58x-config-check.h\"', MBEDTLS_CONFIG_FILE='\"openthread-mbedtls-config.h\"',PACKAGE_NAME='\"Rafael\"',PACKAGE_VERSION='\"1.9.3\"'
  c misc: -fno-exceptions -fdata-sections -ffunction-sections
  c include: ..\..\..\..\..\..\Middleware\Thread\Config\FreeRtos\FTD\Subg;..\..\..\..\..\..\Middleware\Thread\Config_Subg;..\..\..\..\..\..\Middleware\Thread\Source\Include;..\..\..\..\..\..\Middleware\Third_Party\openthread\examples\platforms;..\..\..\..\..\..\Middleware\Third_Party\openthread\examples\platforms\utils;..\..\..\..\..\..\Middleware\Third_Party\openthread\include;..\..\..\..\..\..\Middleware\Third_Party\openthread\include\openthread;..\..\..\..\..\..\Middleware\Third_Party\openthread\src;..\..\..\..\..\..\Middleware\Third_Party\openthread\src\cli;..\..\..\..\..\..\Middleware\Third_Party\openthread\src\core;..\..\..\..\..\..\Middleware\Third_Party\openthread\src\core\api;..\..\..\..\..\..\Middleware\Third_Party\openthread\src\core\backbone_router;..\..\..\..\..\..\Middleware\Third_Party\openthread\src\core\border_router;..\..\..\..\..\..\Middleware\Third_Party\openthread\src\core\coap;..\..\..\..\..\..\Middleware\Third_Party\openthread\src\core\common;..\..\..\..\..\..\Middleware\Third_Party\openthread\src\core\config;..\..\..\..\..\..\Middleware\Third_Party\openthread\src\core\crypto;..\..\..\..\..\..\Middleware\Third_Party\openthread\src\core\diags;..\..\..\..\..\..\Middleware\Third_Party\openthread\src\core\mac;..\..\..\..\..\..\Middleware\Third_Party\openthread\src\core\meshcop;..\..\..\..\..\..\Middleware\Third_Party\openthread\src\core\net;..\..\..\..\..\..\Middleware\Third_Party\openthread\src\core\radio;..\..\..\..\..\..\Middleware\Third_Party\openthread\src\core\thread;..\..\..\..\..\..\Middleware\Third_Party\openthread\src\core\utils;..\..\..\..\..\..\Middleware\Third_Party\openthread\third_party\mbedtls;..\..\..\..\..\..\Middleware\Third_Party\openthread\third_party\mbedtls\repo\include;..\..\..\..\..\..\Middleware\Third_Party\openthread\third_party\mbedtls\repo\include\mbedtls;..\..\..\..\..\..\Middleware\Third_Party\openthread\third_party\mbedtls\repo\include\psa;..\..\..\..\..\..\Middleware\Third_Party\openthread\third_party\mbedtls\repo\library;..\..\..\..\..\..\Middleware\Third_Party\openthread\third_party\tcplp;..\..\..\..\..\..\Middleware\Third_Party\openthread\third_party\tcplp\lib;..\..\..\..\..\..\Middleware\Third_Party\openthread\third_party\tcplp\bsdtcp;..\..\..\..\..\..\Middleware\MemoryMgmt\Include;..\..\..\..\..\..\Middleware\Portable\bsp_for_ref_design\bsp_for_thread\Include;..\..\..\..\..\..\Middleware\Portable\Utility\include;..\..\..\..\..\..\Middleware\Portable\Uart\Include;..\..\..\..\..\..\Middleware\Portable\System\Include;..\..\..\..\..\..\Middleware\RFB\include;..\..\..\..\..\..\Middleware\RUCI\include;..\..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\..\Library\RT58x\Include;..\..\..\..\..\..\Library\RT58x\Crypto\include;..\..\..\..\..\..\Library\RT58x\Peripheral\Include;..\..\..\..\..\..\Library\RT58x\PHY\include;..\..\..\..\..\..\Library\RT58x\PHY\rt569mp\include;..\..\..\..\..\..\Middleware\Third_Party\FreeRTOS\Source\include;..\..\..\..\..\..\Middleware\Third_Party\FreeRTOS\Source\portable\GCC\ARM_CM3;..\..\..\..\..\..\Middleware\FOTA\Include;..\..\..\..\..\..\Middleware\BLE\BLE_Host\Include;..\..\..\..\..\..\Middleware\BLE\BLE_Service\BLE_Service_Common\Include;..\..\..\..\..\..\Middleware\BLE\BLE_Service\DIS\Include;..\..\..\..\..\..\Middleware\BLE\BLE_Service\GAPS\Include;..\..\..\..\..\..\Middleware\BLE\BLE_Service\GATTS\Include;..\..\..\..\..\..\Middleware\BLE\BLE_Service\TRSPS\Include;..\..\..\..\..\..\Middleware\RF_FW_Control_Task\Include;..\BLE_App_Profile\Include;..\Include;..\..\..\..\..\..\Middleware\Third_Party\uecc
  asm define: USE_FREERTOS
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\ToggleSubGBLE_FTD.sct
  group OT-API
    ../../../../../../Middleware/Third_Party/openthread/src/core/api/: backbone_router_api.cpp backbone_router_ftd_api.cpp ble_secure_api.cpp border_agent_api.cpp border_router_api.cpp border_routing_api.cpp channel_manager_api.cpp channel_monitor_api.cpp child_supervision_api.cpp coap_api.cpp coap_secure_api.cpp commissioner_api.cpp crypto_api.cpp dataset_api.cpp dataset_ftd_api.cpp dataset_updater_api.cpp diags_api.cpp dns_api.cpp dns_server_api.cpp error_api.cpp heap_api.cpp history_tracker_api.cpp icmp6_api.cpp instance_api.cpp ip6_api.cpp jam_detection_api.cpp joiner_api.cpp link_api.cpp link_metrics_api.cpp link_raw_api.cpp logging_api.cpp mdns_api.cpp mesh_diag_api.cpp message_api.cpp multi_radio_api.cpp nat64_api.cpp netdata_api.cpp netdata_publisher_api.cpp netdiag_api.cpp network_time_api.cpp ping_sender_api.cpp radio_stats_api.cpp random_crypto_api.cpp random_noncrypto_api.cpp server_api.cpp sntp_api.cpp srp_client_api.cpp srp_client_buffers_api.cpp srp_server_api.cpp tasklet_api.cpp tcp_api.cpp tcp_ext_api.cpp thread_api.cpp thread_ftd_api.cpp trel_api.cpp udp_api.cpp verhoeff_checksum_api.cpp
  group OT-Backbone_Router
    ../../../../../../Middleware/Third_Party/openthread/src/core/backbone_router/: backbone_tmf.cpp bbr_leader.cpp bbr_local.cpp bbr_manager.cpp multicast_listeners_table.cpp ndproxy_table.cpp
  group OT-Border_Router
    ../../../../../../Middleware/Third_Party/openthread/src/core/border_router/: infra_if.cpp routing_manager.cpp
  group OT-COAP
    ../../../../../../Middleware/Third_Party/openthread/src/core/coap/: coap.cpp coap_message.cpp coap_secure.cpp
  group OT-Common
    ../../../../../../Middleware/Third_Party/openthread/src/core/common/: appender.cpp binary_search.cpp data.cpp error.cpp frame_builder.cpp frame_data.cpp heap.cpp heap_data.cpp heap_string.cpp log.cpp message.cpp notifier.cpp offset_range.cpp preference.cpp random.cpp settings.cpp string.cpp tasklet.cpp time_ticker.cpp timer.cpp tlvs.cpp trickle_timer.cpp uptime.cpp crc16.cpp
  group OT-Crypto
    ../../../../../../Middleware/Third_Party/openthread/src/core/crypto/: aes_ccm.cpp aes_ecb.cpp crypto_platform.cpp hkdf_sha256.cpp hmac_sha256.cpp mbedtls.cpp sha256.cpp storage.cpp
  group OT-Diags
    ../../../../../../Middleware/Third_Party/openthread/src/core/diags/: factory_diags.cpp
  group OT-Instance
    ../../../../../../Middleware/Third_Party/openthread/src/core/instance/: extension_example.cpp instance.cpp
  group OT-MAC
    ../../../../../../Middleware/Third_Party/openthread/src/core/mac/: channel_mask.cpp data_poll_handler.cpp data_poll_sender.cpp link_raw.cpp mac.cpp mac_filter.cpp mac_frame.cpp mac_header_ie.cpp mac_links.cpp mac_types.cpp sub_mac.cpp sub_mac_callbacks.cpp sub_mac_csl_receiver.cpp sub_mac_wed.cpp wakeup_tx_scheduler.cpp
  group OT-Meshcop
    ../../../../../../Middleware/Third_Party/openthread/src/core/meshcop/: announce_begin_client.cpp border_agent.cpp commissioner.cpp dataset.cpp dataset_manager.cpp dataset_manager_ftd.cpp dataset_updater.cpp energy_scan_client.cpp extended_panid.cpp joiner.cpp joiner_router.cpp meshcop.cpp meshcop_leader.cpp meshcop_tlvs.cpp network_name.cpp panid_query_client.cpp secure_transport.cpp tcat_agent.cpp timestamp.cpp
  group OT-Net
    ../../../../../../Middleware/Third_Party/openthread/src/core/net/: checksum.cpp dhcp6_client.cpp dhcp6_server.cpp dns_client.cpp dns_dso.cpp dns_platform.cpp dns_types.cpp dnssd.cpp dnssd_server.cpp icmp6.cpp ip4_types.cpp ip6.cpp ip6_address.cpp ip6_filter.cpp ip6_headers.cpp ip6_mpl.cpp mdns.cpp nat64_translator.cpp nd_agent.cpp nd6.cpp netif.cpp sntp_client.cpp socket.cpp srp_advertising_proxy.cpp srp_client.cpp srp_server.cpp tcp6.cpp tcp6_ext.cpp udp6.cpp
  group OT-Radio
    ../../../../../../Middleware/Third_Party/openthread/src/core/radio/: ble_secure.cpp radio.cpp radio_callbacks.cpp radio_platform.cpp trel_interface.cpp trel_link.cpp trel_packet.cpp
  group OT-Thread
    ../../../../../../Middleware/Third_Party/openthread/src/core/thread/: address_resolver.cpp announce_begin_server.cpp announce_sender.cpp anycast_locator.cpp child.cpp child_supervision.cpp child_table.cpp csl_tx_scheduler.cpp discover_scanner.cpp dua_manager.cpp energy_scan_server.cpp indirect_sender.cpp key_manager.cpp link_metrics.cpp link_metrics_types.cpp link_quality.cpp lowpan.cpp mesh_forwarder.cpp mesh_forwarder_ftd.cpp mesh_forwarder_mtd.cpp mle.cpp mle_router.cpp mle_tlvs.cpp mle_types.cpp mlr_manager.cpp neighbor.cpp neighbor_table.cpp network_data.cpp network_data_leader.cpp network_data_leader_ftd.cpp network_data_local.cpp network_data_notifier.cpp network_data_publisher.cpp network_data_service.cpp network_data_tlvs.cpp network_data_types.cpp network_diagnostic.cpp network_diagnostic_tlvs.cpp panid_query_server.cpp radio_selector.cpp router.cpp router_table.cpp src_match_controller.cpp thread_netif.cpp time_sync_service.cpp tmf.cpp uri_paths.cpp
  group OT-Utils
    ../../../../../../Middleware/Third_Party/openthread/src/core/utils/: channel_manager.cpp channel_monitor.cpp flash.cpp heap.cpp history_tracker.cpp jam_detector.cpp link_metrics_manager.cpp mesh_diag.cpp otns.cpp parse_cmdline.cpp ping_sender.cpp power_calibration.cpp slaac_address.cpp srp_client_buffers.cpp verhoeff_checksum.cpp
  group OT-CLI
    ../../../../../../Middleware/Third_Party/openthread/src/cli/: cli.cpp cli_bbr.cpp cli_br.cpp cli_coap.cpp cli_coap_secure.cpp cli_commissioner.cpp cli_dataset.cpp cli_dns.cpp cli_history.cpp cli_joiner.cpp cli_link_metrics.cpp cli_mac_filter.cpp cli_mdns.cpp cli_network_data.cpp cli_ping.cpp cli_srp_client.cpp cli_srp_server.cpp cli_tcat.cpp cli_tcp.cpp cli_udp.cpp cli_utils.cpp cli_extension_example.c
  group mbedTLS
    ../../../../../../Middleware/Third_Party/openthread/third_party/mbedtls/repo/library/: aes.c aesce.c aesni.c aria.c asn1parse.c asn1write.c base64.c bignum.c bignum_core.c bignum_mod.c bignum_mod_raw.c block_cipher.c camellia.c ccm.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c constant_time.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c ecp_curves_new.c entropy.c entropy_poll.c error.c gcm.c hkdf.c hmac_drbg.c lmots.c lms.c md.c md5.c memory_buffer_alloc.c mps_reader.c mps_trace.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_ecc.c pk_wrap.c pkcs5.c pkcs7.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_aead.c psa_crypto_cipher.c psa_crypto_client.c psa_crypto_driver_wrappers_no_static.c psa_crypto_ecp.c psa_crypto_ffdh.c psa_crypto_hash.c psa_crypto_mac.c psa_crypto_pake.c psa_crypto_rsa.c psa_crypto_se.c psa_crypto_slot_management.c psa_crypto_storage.c psa_its_file.c psa_util.c ripemd160.c rsa.c rsa_alt_helpers.c sha1.c sha3.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_client.c ssl_cookie.c ssl_debug_helpers_generated.c ssl_msg.c ssl_ticket.c ssl_tls.c ssl_tls12_client.c ssl_tls12_server.c ssl_tls13_client.c ssl_tls13_generic.c ssl_tls13_keys.c ssl_tls13_server.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write.c x509write_crt.c x509write_csr.c
  group utils
    ../../../../../../Middleware/Third_Party/openthread/examples/platforms/utils/: debug_uart.c logging_rtt.c settings_ram.c soft_source_match_table.c link_metrics.cpp mac_frame.cpp otns_utils.cpp
  group Platform
    ../../../../../../Middleware/Prebuild/: lib_freertos_thread_SubG_FTD_platform.lib
  group SDK-Driver
    ../../../../../../Library/RT58x/Peripheral/: dma.c flashctl.c flashds.c gpio.c mp_sector.c sysctrl.c sysfun.c timer.c uart_retarget.c wdt.c lpm.c uart_drv.c rtc.c comparator.c flash_protect.c
    ../../../../../../Library/RT58x/Crypto/: aes.c crypto.c crypto_util.c
  group SDK-BSP
    ../../../../../../Middleware/Portable/bsp_for_ref_design/bsp_for_thread/: bsp.c bsp_button.c bsp_led.c
  group SDK-Startup
    ../../../../../../Library/RT58x/Device/: system_cm3_mcu.c
    ../../../../../../Library/RT58x/Device/ARM/: startup_cm3_mcu.s
  group SDK-Utility
    ../../../../../../Middleware/Portable/Utility/: util.c util_list.c util_log.c util_printf.c util_string.c util_queue.c shell.c
  group SDK-Uart
    ../../../../../../Middleware/Portable/Uart/: hosal_uart.c uart_stdio.c
  group SDK-System
    ../../../../../../Middleware/Portable/System/: sys_arch.c sys_taskdbg.c sys_timer.c
  group BLE_Host
    ../../../../../../Middleware/BLE/BLE_Host/: ble_cmd_advertising.c ble_cmd_att_gatt.c ble_cmd_common.c ble_cmd_connect_cte.c ble_cmd_gap.c ble_cmd_privacy.c ble_cmd_scan.c ble_cmd_security_manager.c ble_host_ref.c
    ../../../../../../Middleware/Prebuild/: lib_ble_host.lib
  group BLE_Service
    ../../../../../../Middleware/BLE/BLE_Service/BLE_Service_Common/: ble_service_common.c
    ../../../../../../Middleware/BLE/BLE_Service/GAPS/: ble_service_gaps.c
    ../../../../../../Middleware/BLE/BLE_Service/GATTS/: ble_service_gatts.c
    ../../../../../../Middleware/BLE/BLE_Service/DIS/: ble_service_dis.c
    ../../../../../../Middleware/BLE/BLE_Service/TRSPS/: ble_service_trsps.c
  group BLE_App_Profile
    ../BLE_App_Profile/: ble_profile_app.c ble_profile_def.c
  group Application
    ../: app_commission.c app_uart.c app_udp.c main.c cli_uart.cpp app_ble_task.c app_thread_task.c
  group Config
    ../../../../../../Middleware/Thread/Config/FreeRtos/FTD/Subg/: FreeRTOSConfig.h openthread-core-RT58x-config.h project_config.h
  group FreeRots
    ../../../../../../Middleware/Third_Party/FreeRTOS/Source/: tasks.c list.c queue.c timers.c
    ../../../../../../Middleware/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../freertos/: port.c
software components: CMSIS:CORE 5.5.0
