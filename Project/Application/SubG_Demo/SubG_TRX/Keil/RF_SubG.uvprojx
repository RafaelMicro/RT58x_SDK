# Keil uVision project RF_SubG.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: rf_subg +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\Library\RT58x\Peripheral\Include;..\..\..\..\..\Library\RT58x\PHY\include;..\..\..\..\..\Library\RT58x\include;..\..\..\..\..\Middleware\Third_Party\FreeRTOS\Source\include;..\..\..\..\..\Middleware\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\..\..\..\..\Middleware\RUCI\include;..\config;..\include;..\..\..\..\..\Library\RT58x\PHY\rt569mp\include;..\..\..\..\..\Middleware\Portable\Utility\include;..\..\..\..\..\Middleware\Portable\bsp\include;..\..\..\..\..\Middleware\Portable\System\include;..\..\..\..\..\Middleware\RFB\include;..\RFB_SubG\include;..\..\..\..\..\Library\RT58x\Device\Include;..\..\..\..\..\Middleware\MemoryMgmt\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000 size 0x74000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\RF_SubG.sct
  group Application
    ../: main.c
  group Startup
    ../../../../../Library/RT58x/Device/: system_cm3_mcu.c
    ../../../../../Library/RT58x/Device/ARM/: startup_cm3_mcu.s
  group Library
    ../../../../../Library/RT58x/Peripheral/: dma.c gpio.c sysctrl.c sysfun.c timer.c uart_drv.c wdt.c uart_retarget.c flashctl.c mp_sector.c lpm.c sadc.c
    ../../../../../Library/RT58x/PHY/rt569mp/: rt569mp_fw.c rt569mp_init.c
    ../../../../../Middleware/Prebuild/: lib_rf_mcu.lib
  group Rfb_Middleware
    ../../../../../Middleware/RFB/: rfb.c rfb_comm_common.c rfb_comm_isr.c rfb_port.c rfb_comm_15p4Mac.c rfb_comm_subg.c
  group Rfb_Application
    ../RFB_SUBG/: rfb_sample.c mac_frame_gen.c
  group FreeRTOS
    ../../../../../Middleware/Third_Party/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../../../Middleware/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../../../../../Middleware/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Util_printf
    ../../../../../Middleware/Portable/Utility/: util.c util_list.c util_log.c util_printf.c util_queue.c util_string.c shell.c
  group BSP
    ../../../../../Middleware/Portable/bsp/: bsp.c bsp_button.c bsp_console.c bsp_led.c bsp_uart.c bsp_uart_drv.c
  group CLI
    ../CLI/: cli_cosole.c cli_cmd_sys.c cli_cmd_rf_subg.c
software components: CMSIS:CORE 5.0.1
